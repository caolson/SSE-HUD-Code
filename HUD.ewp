# IAR project HUD.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32f4XX; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: C:\Users\Carl\Documents\HUD Code; C:\Users\Carl\Documents\HUD Code\Utilities; C:\Users\Carl\Documents\HUD Code\Libraries; C:\Users\Carl\Documents\HUD Code\Libraries\STM32F4xx_StdPeriph_Driver\inc; C:\Users\Carl\Documents\HUD Code\Libraries\CMSIS\Include; C:\Users\Carl\Documents\HUD Code\Libraries\CMSIS\ST\STM32F4xx\Include; C:\Users\Carl\Documents\HUD Code\Utilities\STM32F4-Discovery; C:\Users\Carl\Documents\HUD Code\Project
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: HUD.out
  ILINK.IlinkIcfFile: HUD.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: startup_stm32f4xx.s
    ../STM32F4-Discovery_FW_V1.1.0/Project/Peripheral_Examples/SysTick/: system_stm32f4xx.c
  group STM32F4_Discovery
    ../Utilities/STM32F4-Discovery/: stm32f4_discovery.c stm32f4_discovery_lis302dl.c
  group STM32F4xx_StdPeriphDriver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group user
    ./: brake.c brake.h i2c.c i2c.h main.c main.h screen.c screen.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h tach.c tach.h throttle.c throttle.h
